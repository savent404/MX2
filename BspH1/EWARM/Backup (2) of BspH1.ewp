# IAR project Backup (2) of BspH1.ewp, settings and files
configuration BspH1 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xG GD GD32F303xG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; GD32F30X_XD; ARM_MATH_CM4; USE_NP; GD32F303xG; MX_MUX_DUAL_TRACK; USE_DEBUG
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Drivers/GD32F30x_standard_peripheral/Include; ../Drivers/SPI_SD/Inc; ../../MX/AUDIO; ../../MX/Hand; ../../MX/KEY; ../../MX/LED; ../../MX/LOOP; ../../MX/MUX; ../../MX/PARAM; ../../MX/PM; ../../MX/SimpleLED; ../../MX; ../../MX/LED/CXXPort; ../../MX/Console
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: BspH1.bin
  ILINK.IlinkOutputFile: BspH1.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../startup/: startup_stm32f103xe.s
  group Application/Port
    ../Port/: mx_audio_port.c mx_console_port.c mx_hand_port.c mx_key_port.c mx_led_anag_port.c mx_led_digi_port.cpp mx_mux_port.c mx_pm_port.c mx_tf_port.c
  group Application/User
    ../Src/: adc.c dac.c dma.c fatfs.c freertos.c gpio.c iwdg.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c tim.c user_diskio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/GD32F30x_STD_Driver
    ../Drivers/GD32F30x_standard_peripheral/Source/: gd32f30x_ctc.c
  group Drivers/SpiSdDrv
    ../Drivers/SPI_SD/Src/: mmcsd_spi.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: cc932.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TestCase
    ../TestCase/: test_hand.c test_looper.c test_mux.c test_np.c
  group UserApp
    ../../MX/AUDIO/: audio.c audio_defaultPort.c
    ../../MX/Console/: console.c
    ../../MX/Hand/: hand.c
    ../../MX/LED/CXXPort/: iBlade.cpp
    ../../MX/KEY/: key.c
    ../../MX/LED/: LED.c LED_NP.cpp
    ../../MX/LOOP/: LOOP.c
    ../../MX/MUX/: mux.c
    ../../MX/PARAM/: param.c re.c triggerPath.c USR_CONFIG.c
    ../../MX/SimpleLED/: SimpleLED.c
